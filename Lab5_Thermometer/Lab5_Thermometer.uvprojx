# Keil uVision project Lab5_Thermometer.uvprojx, settings and files
target Lab5_Thermometer (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Lab5_Thermometer
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: .\UCOS;.\APP;.\CPU;.\LIB;.\BSP;.\RTE;.\RTE\Device\STM32F103C8
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group APP
    ./APP/: app_cfg.h includes.h os_cfg.h
    ./: app.c
  group UCOS
    ./UCOS/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c ucos_ii.h
  group BSP
    ./BSP/: bsp.h
    ./: bsp.c
  group LIB
    ./LIB/: lib_def.h lib_mem.c lib_mem.h lib_str.c lib_str.h
  group CPU
    ./CPU/: os_cpu.h os_cpu_a.asm os_cpu_c.c os_dbg.c cpu.h cpu_a.asm cpu_c.c cpu_def.h
software components: CMSIS:CORE 3.40.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0
